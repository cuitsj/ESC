# Keil uVision project DMESC.uvprojx, settings and files
target DMESC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMESC +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\PRJ;..\LIB\inc;..\CORE;..\APP\inc;..\Hardware\inc;..\SYSTEM\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group APP
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../APP/src/: MotorControl.c AddFunction.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_ld.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/src/: SysTick.c
  group Hardware
    ../Hardware/src/: GPIOInit.c ADCInit.c TimerInit.c USARTInit.c
